# Keil uVision project project.uvprojx, settings and files
target FREERTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, USE_HAL_DRIVER
  c include: .\applications;.\board;.\board\CubeMX_Config\Inc;.\board\CubeMX_Config\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\board\CubeMX_Config\Drivers\STM32F1xx_HAL_Driver\Inc;.\board\CubeMX_Config\Drivers\CMSIS\Include;.\Hal_Drivers;.\board\CubeMX_Config\Middlewares\Third_Party\FreeRTOS\Source\include;.\board\CubeMX_Config\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\board\CubeMX_Config\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    ./board/CubeMX_Config/Src/: stm32f1xx_it.c
    ./applications/: main.c
  group Drivers
    ./board/: board.c
    ./Hal_Drivers/: drv_common.c drv_gpio.c usart.c
    ./board/CubeMX_Config/MDK-ARM/: startup_stm32f103xe.s
    ./board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
  group FreeRTOS
    ./board/CubeMX_Config/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./board/CubeMX_Config/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ./board/CubeMX_Config/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./board/CubeMX_Config/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group STM32_HAL
    ./board/CubeMX_Config/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
    ./board/CubeMX_Config/Src/: system_stm32f1xx.c
